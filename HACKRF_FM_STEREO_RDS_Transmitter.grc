<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fm_transmitter</value></param>
<param><key>author</key><value>Moskalev Denis</value></param>
<param><key>category</key><value>RDS</value></param>
<param><key>description</key><value>FM Stereo with RDS transmitter</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>88-108 FM Stereo RDS radio transmitter</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>PS</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"DEMOS FM"</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>5,0,1,1</value></param>
<param><key>label</key><value>"PS"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>1067*1e5</value></param>
<param><key>grid_pos</key><value>0,0,1,2</value></param>
<param><key>label</key><value>Freq</value></param>
<param><key>max</key><value>1080*1e5</value></param>
<param><key>min</key><value>875*1e5</value></param>
<param><key>num_steps</key><value>205</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_widht</value></param>
<param><key>value</key><value>120e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fm_max_dev</value></param>
<param><key>value</key><value>75e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hardware_rate</value></param>
<param><key>value</key><value>8e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>outbuffer</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>pilot_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0.19</value></param>
<param><key>grid_pos</key><value>3,0,1,1</value></param>
<param><key>label</key><value>Pilot tone 19KHz</value></param>
<param><key>max</key><value>0.2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>power</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>47</value></param>
<param><key>grid_pos</key><value>7,0,1,1</value></param>
<param><key>label</key><value>TX power</value></param>
<param><key>max</key><value>47</value></param>
<param><key>min</key><value>1</value></param>
<param><key>num_steps</key><value>46</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>radiotext</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>'music heals!'</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>6,0,1,1</value></param>
<param><key>label</key><value>"radiotext"</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rds_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0.08</value></param>
<param><key>grid_pos</key><value>4,0,1,1</value></param>
<param><key>label</key><value>RDS power</value></param>
<param><key>max</key><value>0.2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>420e3</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>sub_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0.75</value></param>
<param><key>grid_pos</key><value>2,0,1,1</value></param>
<param><key>label</key><value>Stereo Volume</value></param>
<param><key>max</key><value>1</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>vol</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0.85</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Mono Volume</value></param>
<param><key>max</key><value>1</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>analog_fm_preemph</key>
<param><key>id</key><value>analog_fm_preemph_0_0_0_0</value></param>
<param><key>fh</key><value>-1</value></param>
<param><key>minoutbuf</key><value>outbuffer</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>tau</key><value>50e-6</value></param>
</block>
<block>
<key>analog_fm_preemph</key>
<param><key>id</key><value>analog_fm_preemph_0_0_0_0_0</value></param>
<param><key>fh</key><value>-1</value></param>
<param><key>minoutbuf</key><value>outbuffer</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>tau</key><value>50e-6</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1_0_0</value></param>
<param><key>amp</key><value>sub_gain</value></param>
<param><key>freq</key><value>38e3</value></param>
<param><key>minoutbuf</key><value>outbuffer</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>channel_widht</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1_1</value></param>
<param><key>amp</key><value>pilot_gain</value></param>
<param><key>freq</key><value>19e3</value></param>
<param><key>minoutbuf</key><value>outbuffer</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>channel_widht</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>num_outputs</key><value>2</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>minoutbuf</key><value>outbuffer</value></param>
<param><key>num_inputs</key><value>4</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>100</value></param>
<param><key>minoutbuf</key><value>outbuffer</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>http://185.33.21.111/atr_128</value></param>
<param><key>minoutbuf</key><value>50000</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>m</key><value>1</value></param>
<param><key>minoutbuf</key><value>outbuffer</value></param>
<param><key>n</key><value>2</value></param>
<param><key>type</key><value>short</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>m</key><value>1</value></param>
<param><key>minoutbuf</key><value>outbuffer</value></param>
<param><key>n</key><value>2</value></param>
<param><key>type</key><value>short</value></param>
<param><key>offset</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>vol</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>vol</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>const</key><value>vol*sub_gain</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_xx</key>
<param><key>id</key><value>blocks_multiply_const_xx_0</value></param>
<param><key>const</key><value>0.000032</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>minoutbuf</key><value>outbuffer</value></param>
</block>
<block>
<key>blocks_multiply_const_xx</key>
<param><key>id</key><value>blocks_multiply_const_xx_0_0</value></param>
<param><key>const</key><value>0.000032</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>minoutbuf</key><value>outbuffer</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>minoutbuf</key><value>outbuffer</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0_0</value></param>
<param><key>interp</key><value>160</value></param>
<param><key>minoutbuf</key><value>outbuffer</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>1234</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>minoutbuf</key><value>outbuffer</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>minoutbuf</key><value>outbuffer</value></param>
<param><key>taps</key><value>firdes.low_pass(1, audio_rate, 15000, 1000)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>minoutbuf</key><value>outbuffer</value></param>
<param><key>taps</key><value>firdes.low_pass(3, audio_rate, 15000, 1000) </value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_2</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>minoutbuf</key><value>outbuffer</value></param>
<param><key>taps</key><value>firdes.low_pass(1, channel_widht, 2.4e3, 0.5e3)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>gr_add_xx_0_0_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>minoutbuf</key><value>outbuffer</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>gr_char_to_float_0_0</value></param>
<param><key>maxoutbuf</key><value>outbuffer</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>digital_diff_encoder_bb</key>
<param><key>id</key><value>gr_diff_encoder_bb_0_0</value></param>
<param><key>maxoutbuf</key><value>outbuffer</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>analog_frequency_modulator_fc</key>
<param><key>id</key><value>gr_frequency_modulator_fc_0</value></param>
<param><key>minoutbuf</key><value>outbuffer</value></param>
<param><key>sensitivity</key><value>2*math.pi*fm_max_dev/samp_rate*0.6</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>gr_map_bb_0_0</value></param>
<param><key>map</key><value>[-1,1]</value></param>
<param><key>maxoutbuf</key><value>outbuffer</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>gr_map_bb_1_0</value></param>
<param><key>map</key><value>[1,2]</value></param>
<param><key>maxoutbuf</key><value>outbuffer</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>gr_multiply_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>minoutbuf</key><value>outbuffer</value></param>
</block>
<block>
<key>gr_rds_encoder</key>
<param><key>id</key><value>gr_rds_encoder</value></param>
<param><key>af1</key><value>center_freq</value></param>
<param><key>ms</key><value>True</value></param>
<param><key>maxoutbuf</key><value>outbuffer</value></param>
<param><key>pi_country_code</key><value>7</value></param>
<param><key>pi_coverage_area</key><value>0</value></param>
<param><key>pi_reference_number</key><value>0</value></param>
<param><key>ps</key><value>PS</value></param>
<param><key>pty_locale</key><value>0</value></param>
<param><key>pty</key><value>11</value></param>
<param><key>radiotext</key><value>radiotext</value></param>
<param><key>ta</key><value>False</value></param>
<param><key>tp</key><value>False</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>gr_sig_source_x_0_0_0</value></param>
<param><key>amp</key><value>rds_gain</value></param>
<param><key>freq</key><value>57e3</value></param>
<param><key>minoutbuf</key><value>outbuffer</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>channel_widht</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>gr_unpack_k_bits_bb_0_0</value></param>
<param><key>k</key><value>2</value></param>
<param><key>maxoutbuf</key><value>outbuffer</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>bw0</key><value>0.25e6</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>if_gain0</key><value>power</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>args</key><value>hackrf,bias_tx=0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>hardware_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>int(channel_widht/1000)</value></param>
<param><key>interp</key><value>int(samp_rate/1000)</value></param>
<param><key>minoutbuf</key><value>outbuffer</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>int(audio_rate/100)</value></param>
<param><key>interp</key><value>int(channel_widht/100)</value></param>
<param><key>minoutbuf</key><value>outbuffer</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_2</value></param>
<param><key>decim</key><value>int(samp_rate/10000)</value></param>
<param><key>interp</key><value>int(hardware_rate/10000)</value></param>
<param><key>minoutbuf</key><value>100000</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_3_1</value></param>
<param><key>decim</key><value>int(audio_rate)/100</value></param>
<param><key>interp</key><value>int(channel_widht)/100</value></param>
<param><key>minoutbuf</key><value>outbuffer</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_4_0</value></param>
<param><key>decim</key><value>380</value></param>
<param><key>interp</key><value>int(channel_widht/1000)</value></param>
<param><key>minoutbuf</key><value>outbuffer</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>grid_pos</key><value>1,1,7,1</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>30</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>20</value></param>
<param><key>samp_rate</key><value>channel_widht</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>float</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>20</value></param>
</block>
<connection><source_block_id>analog_fm_preemph_0_0_0_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_preemph_0_0_0_0_0</source_block_id><sink_block_id>rational_resampler_xxx_3_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_1_0_0</source_block_id><sink_block_id>blocks_multiply_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_1_1</source_block_id><sink_block_id>blocks_add_xx_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_2</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_2</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0</source_block_id><sink_block_id>blocks_short_to_float_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_sub_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>gr_add_xx_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_sub_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>gr_add_xx_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>fir_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1_0</source_block_id><sink_block_id>blocks_add_xx_2</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_repeat_0_0</source_block_id><sink_block_id>rational_resampler_xxx_4_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>blocks_multiply_const_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_1</source_block_id><sink_block_id>blocks_multiply_const_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu</source_block_id><sink_block_id>gr_rds_encoder</sink_block_id><source_key>pdus</source_key><sink_key>rds in</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>analog_fm_preemph_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_1</source_block_id><sink_block_id>analog_fm_preemph_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_2</source_block_id><sink_block_id>gr_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_add_xx_0_0_0_1</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_char_to_float_0_0</source_block_id><sink_block_id>blocks_repeat_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_diff_encoder_bb_0_0</source_block_id><sink_block_id>gr_map_bb_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_frequency_modulator_fc_0</source_block_id><sink_block_id>rational_resampler_xxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_map_bb_0_0</source_block_id><sink_block_id>gr_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_map_bb_1_0</source_block_id><sink_block_id>gr_unpack_k_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_0_0</source_block_id><sink_block_id>blocks_add_xx_2</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>gr_rds_encoder</source_block_id><sink_block_id>gr_diff_encoder_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_sig_source_x_0_0_0</source_block_id><sink_block_id>gr_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_unpack_k_bits_bb_0_0</source_block_id><sink_block_id>gr_map_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>gr_frequency_modulator_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>blocks_add_xx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_2</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_3_1</source_block_id><sink_block_id>blocks_multiply_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_4_0</source_block_id><sink_block_id>fir_filter_xxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
